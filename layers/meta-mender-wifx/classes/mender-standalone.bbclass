# Class for those who want to disable systemd service for Mender

MENDER_FEATURES_DISABLE_append = " \
    mender-systemd \
"