# Copyright (c) 2022, Wifx Sarl <info@iot.wifx.net>
# All rights reserved.

require recipes-bsp/u-boot/u-boot-mender.inc
require u-boot-mender-wifx.inc
require u-boot-mender-wifx-common.inc
