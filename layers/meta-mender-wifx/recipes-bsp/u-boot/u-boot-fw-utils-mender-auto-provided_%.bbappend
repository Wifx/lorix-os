# Copyright (c) 2022, Wifx Sarl <info@iot.wifx.net>
# All rights reserved.

require u-boot-mender-wifx-common.inc
