require pmcli.inc

PR = "r0"

SRC_URI[md5sum] = "e54d1957e9c3c6f5f5c6b9be6814b461"
