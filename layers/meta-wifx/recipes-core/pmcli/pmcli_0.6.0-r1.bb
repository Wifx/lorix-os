require pmcli.inc

PR = "r0"

SRC_URI[md5sum] = "a952b763220ca3a05baa24a80783890d"
