require opkg-status-diff.inc

PR = "r0"

SRC_URI[md5sum] = "aa0cb3fd04c80bd99cf5313c0ea90567"
