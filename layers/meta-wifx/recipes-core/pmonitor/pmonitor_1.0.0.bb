require pmonitor.inc

PR = "r0"

SRC_URI[md5sum] = "aeb0c72431320bfee2420198afc714e1"
