require pmonitor.inc

PR = "r0"

SRC_URI[md5sum] = "c2274d4e0bca3a3a1c432d25cd161125"
