require pmonitor.inc

PR = "r0"

SRC_URI[md5sum] = "d638736bde126c1a10562f147ca73949"
