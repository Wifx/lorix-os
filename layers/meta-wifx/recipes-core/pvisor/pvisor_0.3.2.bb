require pvisor.inc

PR = "r0"

SRC_URI[md5sum] = "1883bd20bbe85d7cd61658dbf2365a0e"
