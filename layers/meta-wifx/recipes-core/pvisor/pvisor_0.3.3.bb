require pvisor.inc

PR = "r0"

SRC_URI[md5sum] = "3a4085fcf94adca183309a6494e7a71d"
