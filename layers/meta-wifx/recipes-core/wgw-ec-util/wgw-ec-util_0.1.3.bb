require wgw-ec-util.inc

PR = "r0"

SRC_URI[md5sum] = "3ac3cc9b2e30cf142200c3e632544ece"