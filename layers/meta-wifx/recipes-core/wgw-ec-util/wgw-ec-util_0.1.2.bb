require wgw-ec-util.inc

PR = "r0"

SRC_URI[md5sum] = "573e8fa4262827e657e86cfe3c086f4c"