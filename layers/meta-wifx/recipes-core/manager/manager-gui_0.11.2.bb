require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "dcf3347508b637ca33e6ac82ca86fc13"
