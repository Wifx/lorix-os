require manager.inc

PR = "r0"

SRC_URI[md5sum] = "7666ee6e24a6c7219e5ac838200c664c"
