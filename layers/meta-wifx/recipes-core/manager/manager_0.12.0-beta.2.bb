require manager.inc

PR = "r0"

SRC_URI[md5sum] = "a2a8b8cf4e982b0a9bd56fc003fe0e48"
