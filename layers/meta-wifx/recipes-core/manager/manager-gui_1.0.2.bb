require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "8858a7aebe0063d046ba529632d57d53"
