require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "ffb95fce368abf04d01b7a40946edcfc"
