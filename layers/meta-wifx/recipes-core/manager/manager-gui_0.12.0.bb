require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "8c370e40c2725980a2d62cb7aa321ae8"
