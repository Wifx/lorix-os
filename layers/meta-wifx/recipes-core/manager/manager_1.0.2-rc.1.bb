require manager.inc

PR = "r0"

SRC_URI[md5sum] = ""
