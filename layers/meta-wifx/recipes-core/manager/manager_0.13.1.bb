require manager.inc

PR = "r0"

SRC_URI[md5sum] = "c90c3fe9602c04cbe2b7df7849449619"
