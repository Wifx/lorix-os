require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "db1f89861dae56d50f84b01b623b60fb"
