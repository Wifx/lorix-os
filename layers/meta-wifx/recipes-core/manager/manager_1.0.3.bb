require manager.inc

PR = "r0"

SRC_URI[md5sum] = "233a5fa35e9e441451d3fca08bf74b5a"
