require manager.inc

PR = "r0"

SRC_URI[md5sum] = "2b61e05b8ceee6c0a207a3e23cde5f05"
