require manager.inc

PR = "r0"

SRC_URI[md5sum] = "1f65e34fdca1cc1991c4da16fddfbff7"
