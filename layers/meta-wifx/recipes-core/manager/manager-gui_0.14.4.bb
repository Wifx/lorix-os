require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "f9f0d061443a9002cbbb32b331933801"
