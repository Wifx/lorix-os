require manager.inc

PR = "r0"

SRC_URI[md5sum] = "7d40dcd41219d49b19edeefeb2fb1613"
