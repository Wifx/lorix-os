require manager.inc

PR = "r0"

SRC_URI[md5sum] = "5fae65fe19f6ed2bd739ee3a78c481b1"
