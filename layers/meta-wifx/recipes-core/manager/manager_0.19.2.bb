require manager.inc

PR = "r0"

SRC_URI[md5sum] = "52102b6c291aa9d97a4338cd7284b958"
