require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "cd55d766feaebd90e12982193d0d1712"
