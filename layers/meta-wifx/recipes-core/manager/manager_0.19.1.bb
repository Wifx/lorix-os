require manager.inc

PR = "r0"

SRC_URI[md5sum] = "9cfce081c568fea9d161676e7180e300"
