require manager.inc

PR = "r0"

SRC_URI[md5sum] = "bbb8b31732007a353fff81aa10fd6928"
