require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "3cb1b58bcc13d5ac87c7f37ee5c98f21"
