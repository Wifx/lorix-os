require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "6796b8858aab7a51c059d16b19930fd7"
