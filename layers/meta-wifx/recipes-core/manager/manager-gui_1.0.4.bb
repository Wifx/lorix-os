require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "882a47906edbd33af185064b9e81fac0"
