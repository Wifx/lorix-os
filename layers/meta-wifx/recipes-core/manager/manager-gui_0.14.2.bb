require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "b53c306e45a2a18c4d7f2c895fea9772"
