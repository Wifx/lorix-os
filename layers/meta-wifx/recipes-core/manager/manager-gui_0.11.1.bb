require manager-gui.inc

PR = "r0"

SRC_URI[md5sum] = "b4b90cc32552aaa1c05d0f6abe9b43af"
