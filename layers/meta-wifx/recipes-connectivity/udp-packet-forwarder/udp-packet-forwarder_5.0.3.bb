require udp-packet-forwarder.inc

SRC_URI[md5sum] = "3fd8b6aa69b03234917cefeef43546b4"
