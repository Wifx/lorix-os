require udp-packet-forwarder.inc

SRC_URI[md5sum] = "3c74c313c33efeec6264750ea3624e0b"
