require udp-packet-forwarder.inc

SRC_URI[md5sum] = "ea64b18f1a605b937a98c4762b527e41"
