# Copyright (c) 2022, Wifx SA <info@iot.wifx.net>
# All rights reserved.

PROVIDES += "virtual/firststage"
