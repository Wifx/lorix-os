require linux-mchp.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

LINUX_VERSION_SHORT = "6.12"
LINUX_VERSION = "6.12.48"
LINUX_VERSION_EXTENSION = "-wifx"

SRCREV_machine = "f7b280884bccc5727af6dff1a70678fe3a47d2ce"
SRCREV_meta = "7a8d96185b9be165feb974fe6297b518f83b3b9c"
