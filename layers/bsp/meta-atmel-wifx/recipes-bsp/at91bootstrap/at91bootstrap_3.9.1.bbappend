# Copyright (c) 2019-2020, Wifx Sàrl <info@wifx.net>
# All rights reserved.

require at91bootstrap_3.9.1.inc

PROVIDES += "virtual/firststage"

