require linux-at91-5.4.inc

LINUX_VERSION ?= "5.4.41"

PR = "r0"

SRCREV = "335e2dd74007819a115a1b87b9e03e5be410f096"
KBRANCH = "linux-5.4-at91"
