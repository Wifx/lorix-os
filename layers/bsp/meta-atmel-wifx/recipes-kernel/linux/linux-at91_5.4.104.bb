require linux-at91-5.4.inc

LINUX_VERSION ?= "5.4.104"

PR = "r0"

SRCREV = "0274503d094cdabe38be5355642586cd57e50772"
