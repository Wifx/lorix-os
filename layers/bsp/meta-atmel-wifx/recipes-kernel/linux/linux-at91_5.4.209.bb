require linux-at91-5.4.inc

LINUX_VERSION ?= "5.4.209"

PR = "r0"

SRCREV = "023cd5d2638fad8a7352cca4c4ec3bef4d19f891"
