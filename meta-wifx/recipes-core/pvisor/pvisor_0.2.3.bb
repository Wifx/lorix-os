require pvisor.inc

PR = "r0"

SRC_URI[md5sum] = "82aec580d88ecd20a08fb8147100cf4a"
