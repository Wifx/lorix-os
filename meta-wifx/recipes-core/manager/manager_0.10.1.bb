require manager.inc

PR = "r0"

SRC_URI[md5sum] = "523a83f681f0f4e2963616f5f6870cf8"
