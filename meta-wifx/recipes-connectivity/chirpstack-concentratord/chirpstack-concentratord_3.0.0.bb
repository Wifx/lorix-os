require chirpstack-concentratord.inc

PR = "r0"
