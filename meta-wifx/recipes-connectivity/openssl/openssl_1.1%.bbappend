# Add devcrypto support
PACKAGECONFIG = "cryptodev-linux"
