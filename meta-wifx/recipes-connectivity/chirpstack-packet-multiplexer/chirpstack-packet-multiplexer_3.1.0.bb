require chirpstack-packet-multiplexer.inc

PR = "r0"
