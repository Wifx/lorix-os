# Copyright (c) 2019-2020, Wifx Sàrl <info@wifx.net>
# All rights reserved.

# Override ubi image generation
IMAGE_CLASSES += " wifx-ubimg wifx-wimg"
