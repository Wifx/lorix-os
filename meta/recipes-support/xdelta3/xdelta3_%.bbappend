PACKAGECONFIG += "lzma"