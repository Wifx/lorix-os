PACKAGECONFIG = "tiny"