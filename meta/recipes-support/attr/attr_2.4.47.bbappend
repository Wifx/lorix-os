# doesn't support Pie flags
SECURITY_CFLAGS_pn-${PN} = "${SECURITY_NOPIE_CFLAGS}"
SECURITY_LDFLAGS_pn-${PN} = ""
