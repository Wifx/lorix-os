include upx-native-4.inc

SRCREV = "2f083f3e566786b2b38d7d556bd9c385473dcc6e"
SRC_URI = "  \
    gitsm://github.com/upx/upx;protocol=https;branch=devel4 \
"
PR = "r0"
