include upx-3.inc

SRC_URI = "  \
    git://github.com/upx/upx;protocol=https;tag=v${PV} \
"
PR = "r0"
