# Copyright (c) 2019, Wifx SA <info@wifx.net>
# All rights reserved.

DESCRIPTION = "A complete image supporting all the material to have a OS system without dev/debug tools"
LICENSE = "MIT"
PR = "r0"

inherit wifx-image-core wifx-image-base-users
