require opkg-status-diff.inc

PR = "r0"

SRC_URI[md5sum] = "af49e981369141d4c0b04f35a3915f45"
