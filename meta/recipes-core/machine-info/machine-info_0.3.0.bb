require machine-info.inc

PR = "r0"

#SRC_URI[md5sum] = "9387a6a46541bc327ecbc7f878351b56"