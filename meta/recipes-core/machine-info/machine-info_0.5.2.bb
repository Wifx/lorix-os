require machine-info.inc

PR = "r0"

SRC_URI[md5sum] = "2e3ca101d5a67a8f6b633dc0f92bdd0b"
