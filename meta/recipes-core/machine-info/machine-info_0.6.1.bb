require machine-info.inc

PR = "r0"

SRC_URI[md5sum] = "c4ce20a4d1df186e9b6d8fbb5210cfa5"
