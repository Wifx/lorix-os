require machine-info.inc

PR = "r0"

SRC_URI[md5sum] = "8426fde319775f3bd3e2b1d27b2c7932"