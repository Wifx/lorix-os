require machine-info.inc

PR = "r0"

SRC_URI[md5sum] = "f12754a43163f43d647f6f6f7e0f0076"
