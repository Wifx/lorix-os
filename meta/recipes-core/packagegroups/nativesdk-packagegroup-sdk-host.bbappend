RDEPENDS:${PN}:remove = "nativesdk-qemu nativesdk-qemu-helper"
