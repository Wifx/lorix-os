# doesn't support Pie flags
# TODO: kirkstone check restore these two lines
#SECURITY_CFLAGS:pn-${PN} = "${SECURITY_NOPIE_CFLAGS}"
#SECURITY_LDFLAGS:pn-${PN} = ""
