# Copyright (c) 2022, Wifx Sarl <info@iot.wifx.net>
# All rights reserved.

PACKAGECONFIG = "ipv6"
