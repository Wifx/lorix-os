require chirpstack-concentratord.inc

SRCREV = "${AUTOREV}"
SRC_URI += "git://github.com/Wifx/chirpstack-concentratord.git;protocol=git;branch=lorix-one-config"
PR = "r2"
