require chirpstack-concentratord.inc

SRC_URI += "git://github.com/brocaar/chirpstack-concentratord.git;protocol=https;tag=v${PV}"
PR = "r1"
