require chirpstack-gateway-bridge.inc

PR = "r0"
