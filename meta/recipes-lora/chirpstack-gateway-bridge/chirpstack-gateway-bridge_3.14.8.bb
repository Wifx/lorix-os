require chirpstack-gateway-bridge.inc

PR = "r1"

SRCREV = "347ad67f39f11eb9ec8c9c71e2465e5fc09f7b5a"
