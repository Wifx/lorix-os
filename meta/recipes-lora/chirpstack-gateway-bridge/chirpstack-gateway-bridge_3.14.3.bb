require chirpstack-gateway-bridge.inc

PR = "r0"

SRC_URI += " \
    file://0002-fix-gover-and-dependencies-sum.patch \
"
