require chirpstack-packet-multiplexer.inc

SRC_URI += "git://github.com/brocaar/chirpstack-packet-multiplexer.git;protocol=https;branch=master"
SRCREV = "d9441bc59d1d59fcb7160ecabd1da86c89e82e0d"

PR = "r0"
