include loriot-packet-forwarder.inc
PR = "r0"

SRC_URI += " \
	file://loriot_lorix_one_SPI_2.8.1315-JKS-master-83 \
"

BIN_SRC_FILE_NAME = "loriot_lorix_one_SPI_2.8.1315-JKS-master-83"

COMPATIBLE_MACHINE = "lorix"
