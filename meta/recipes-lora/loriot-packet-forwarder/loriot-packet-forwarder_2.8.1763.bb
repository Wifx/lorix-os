include loriot-packet-forwarder.inc
PR = "r0"

SRC_URI += " \
	file://loriot_wifx_l1_SPI_2.8.1763-DEV \
"

BIN_SRC_FILE_NAME = "loriot_wifx_l1_SPI_2.8.1763-DEV"

COMPATIBLE_MACHINE = "l1"
