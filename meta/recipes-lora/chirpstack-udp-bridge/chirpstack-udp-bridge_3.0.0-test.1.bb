require chirpstack-udp-bridge.inc

SRC_URI += "git://github.com/brocaar/chirpstack-udp-bridge.git;protocol=git;tag=v${PV}"
PR = "r0"
