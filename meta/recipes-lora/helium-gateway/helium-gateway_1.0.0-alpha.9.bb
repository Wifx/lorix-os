require helium-gateway.inc

SRC_URI += "git://github.com/helium/gateway-rs.git;protocol=git;branch=main;tag=v${PV}"
PR = "r0"
