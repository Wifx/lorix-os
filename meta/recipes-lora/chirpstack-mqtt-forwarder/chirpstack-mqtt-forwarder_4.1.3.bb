require chirpstack-mqtt-forwarder.inc

SRC_URI += "git://github.com/chirpstack/chirpstack-mqtt-forwarder.git;protocol=https;branch=master"
SRCREV = "b91df380506105d7b3d60a27b9aa449612853cca"

PR = "r0"
